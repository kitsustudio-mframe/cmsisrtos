# Keil uVision project rtos_cmsisrtos.uvprojx, settings and files
target cm0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: rtos_cmsisrtos_m0 (library)
  AfterMake: cmd.exe /C copy .keil\cm0\Objects\rtos_cmsisrtos_m0.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\;.\resources
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: CmsisrtosConfig.h CmsisrtosConfigDefault.cpp CmsisrtosConfigDefault.h CmsisrtosKernel.cpp CmsisrtosKernel.h CmsisrtosThread.cpp CmsisrtosThread.h package-info.h
  group rtx
    ./rtx/: cmsis_os2.h os_tick.h RTX_CM0.lib RTX_CM3.lib RTX_CM4F.lib rtx_def.h rtx_evr.h rtx_os.h rtx_lib.c
  group resource
    ./resources/: RTX_Config.c RTX_Config.h
target cm3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rtos_cmsisrtos_m3 (library)
  AfterMake: cmd.exe /C copy .keil\cm3\Objects\rtos_cmsisrtos_m3.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\;.\resources
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cm4f (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtos_cmsisrtos_m4f (library)
  AfterMake: cmd.exe /C copy .keil\cm4f\Objects\rtos_cmsisrtos_m4f.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\;.\resources
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
